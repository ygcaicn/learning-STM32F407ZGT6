# Keil uVision project USART.uvprojx, settings and files
target WORK (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usart +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User\Inc;..\System\delay;..\System\sys;..\System\usart;..\Hardware\Led;..\Hardware\Beep;..\Hardware\Key;..\Core;..\Libraries\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/Src/: main.c system_stm32f4xx.c
  group HARDWAER
    ../Hardware/Led/: led.c
    ../Hardware/Beep/: Beep.c
    ../Hardware/Key/: key.c
  group SYSTEM
    ../System/sys/: sys.c
    ../System/delay/: delay.c
    ../System/usart/: usart.c
  group STM32_LIB
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group MDK_STARTUP
    ../Core/: startup_stm32f40_41xxx.s
  group README
    ../Readme/: readme.txt
